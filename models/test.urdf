Commit message: added models

File: models/test.urdf (robot description, URDF)
Before this commit: robot hollow.urdf, 2 links, 1 joints
Links:
- link baseLink: geometry collision mesh filename=boltandnut.obj scale=0.2 0.2 0.2
